<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\01_led_blink.ewp</path>
  </project>
  <batchBuild />
</workspace>
